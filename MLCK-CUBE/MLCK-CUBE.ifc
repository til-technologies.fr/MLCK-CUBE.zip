Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-11T15:12:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 11 15:12:49 2018 * Host: B3ROBRAWR4425 * Database: C:\Users\DDA\AppData\Local\Temp\{AFDD70D9-696E-44A9-8431-0A08D5EFD2FF}\ifc * Database version: 5507 * Database creation date: Mon Jun 11 15:12:46 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Jun 11 15:12:47 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 11 15:12:47 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: MLCK_CUBE, E_Access Control_Controller_MEPContent_TIL Technologies_Specialised modules_FR-EN:MLCK_CUBE:1288045
In: V00
Type - Material: RAL 7016, RAL 9005, RAL 3031, Color RGB 022-063-031, RAL 5012
Type - Dimensions - Depth: 30 mm; Height: 110 mm; Width: 86 mm
Type - Electrical - Humidity Range: 0 to 95% without condensation; Maximum Connection Distance: 600m; Maximum Voltage: 48 V; Operating Temperature: -10°C to +55°C; Voltage: 10 to 28 VDC
Type - Identity Data - Article Description: EQUILOCK Intrusion module for TILLYS NG - 2 buses of 32 EQUILOCK transponders - DIN rail mouting; Article Type: MLCK_CUBE; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: EQUILOCK Intrusion module for TILLYS NG - 2 buses of 32 EQUILOCK transponders - DIN rail mouting; EMCS Version: 3.0; ETIM Article Class: EC000783; Family Version: 11.15; Manufacturer: TIL Technologies; Manufacturer Art. No.: MLCK_CUBE; Manufacturer URL: http://www.til-technologies.com; MEPcontent Class: ACCESS_CONTROL_CONTROLLER; Model: MLCK_CUBE; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; Product Line: NG series; Revit Version: 2017; Type Name: MLCK_CUBE; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Other - Category: Security Devices; Family Name: E_Access Control_Controller_MEPContent_TIL Technologies_Specialised modules_FR-EN; Geometry Visibility 1: yes; Geometry Visibility 2: yes; Geometry Visibility 3: yes; Geometry Visibility 4: yes; Geometry Visibility 5: no
Pset_BuildingElementProxyCommon - Reference: MLCK_CUBE; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: TIL Technologies
Constraints - Offset: 0 mm
Dimensions - Area: 0.0178793 m2; Volume: 0.000275349 m3
Identity Data - Design Option: Main Model; Mark: 1
Other - Family: E_Access Control_Controller_MEPContent_TIL Technologies_Specialised modules_FR-EN: MLCK_CUBE; Family and Type: E_Access Control_Controller_MEPContent_TIL Technologies_Specialised modules_FR-EN: MLCK_CUBE; Type: E_Access Control_Controller_MEPContent_TIL Technologies_Specialised modules_FR-EN: MLCK_CUBE; Type Id: E_Access Control_Controller_MEPContent_TIL Technologies_Specialised modules_FR-EN: MLCK_CUBE
Phasing - Phase Created: 4. Plan over 10 years
